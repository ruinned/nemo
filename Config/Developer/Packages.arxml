<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-3-0.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="8EB547DD-ADBF-4209-BB68-6F7AB272E36C">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C061C785-5F20-462A-AAF1-673023AA256F">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7D593BC0-8CD1-458E-839E-568567832585">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BD939944-D7FA-4DA7-A51F-24C8142BEC81">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E78446D1-A402-493B-9726-E1E047D9AA67">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="60262465-9297-4B63-8BF0-1CD64EEA5A46">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="86D471D8-2C39-4296-BD34-479375A30B43">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D2A3A03C-9FB3-4705-BA16-80E3553305C3">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AECAFF6B-650A-4769-91C8-E444459F3B36">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="157140BA-C429-4A40-AAF7-E0D0CB44D28B">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7D902088-C6FA-4C2E-BEB8-6923B0A86B57">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="17ADDAB9-C560-4347-804C-047E32C6F5CD">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="192BED09-C14A-47D4-99B2-3524C03D84CF">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E061BC53-C9E3-4713-9BF5-FD7F8975E965">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="74EBE72F-504B-4C3C-AAD6-36ABA298ED69">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2BCBE36C-5477-46D7-85D2-B0B04E7B8C1F">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DA45E076-28C9-47A1-B77F-0FFD123CE216">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="128754E8-D85F-41C1-8833-FC61AFB07A65">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0387C8C1-0852-4359-92BB-431B0B91FEAB">
      <SHORT-NAME>PEPS</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="6A545ADC-B3E0-4ADD-B455-0EB119B04672">
          <SHORT-NAME>ComponentTypes_PEPS</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7BA9234F-5805-49B5-A500-62DEA87D168C">
          <SHORT-NAME>IDT_PEPS</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1CB6C5DB-D189-48A3-8F66-E436EC453E65">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="927C8426-825E-46F7-92FC-AEC5CF32A555">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2096EE5B-185C-4153-BA74-0AB53EC0F4A7">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6251928D-24B5-4AA9-B1FD-0B9AC990C8FA">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5E17F85D-E61C-4830-92D2-78B9B21EBE70">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2C56EF13-B74D-4587-9244-F785ED34A39D">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D1359128-2DCD-4279-AA2D-44C2D943F33B">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1B618746-33F4-45A5-A978-2CC44855AB52">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D671C043-35F2-4EA3-BD54-2360637693EA">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E7836B1E-A2BA-4FE2-9BF9-CA757AE842DF">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BD90647B-AE28-46FE-B505-9A499FB3D76C">
          <SHORT-NAME>Unit</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B8562400-6933-47A0-9284-9DC30C508917">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="9BF50F08-4050-459E-983D-8B9090A7EA31">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9BD7F313-534F-48CA-8EC8-80A9866975D4">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2BF7F0AD-E9D1-4EE0-960E-6FE5FF979F3A">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7D9CAAF8-4B6A-479A-B9DA-A796D3EAAAEA">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0F1B2892-77A2-4E46-A06B-5E97E9F578B6">
      <SHORT-NAME>SCIM_DataTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A1A0D945-7B95-4FE0-A169-5EE87B8D6FFD">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="704F5B86-0E7E-410C-9D02-F549DF05A284">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="615BBB89-FCEB-4B53-BA66-6D83F8500A79">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="88290e78-e1f3-4cb2-9a99-68c2cb8c25b0">
      <SHORT-NAME>cdd_lfic</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="954808d1-9ae0-4f92-b5a4-5cc96099a50b">
      <SHORT-NAME>cdd_rfic</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="a9a7242d-4d32-476a-9c1a-35eed0bc43b9">
      <SHORT-NAME>cdd_spi</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2e223d59-fd3e-4200-b4d8-ce8722405047">
          <SHORT-NAME>CddSwComponentTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A8A6F0D-A379-4257-A991-8758726E1535">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FE6041E3-B153-4381-B8CB-6FBAE055AF18">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C24B6BDB-E441-45F4-92BC-8DACD7CD904F">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CC9E854F-FA2F-4B66-BC95-9A568E5BC350">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A778C249-F8BC-45C8-B7F2-9E1B61BEEB22">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="22F317E0-B12C-48F7-8178-F9D7D86E2AB8">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="FDFF7A61-4E6A-4407-84F9-292DFDA3BD24">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4FEC0FEF-74BD-414B-8D05-E2090C1B1A9E">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C505CB1D-B2F2-4377-A312-E73077C6AAF2">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="35D8FB40-8C20-430F-B275-58834B4203A5">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3377ce6a-682a-4de9-9e4f-f4aea8dd96cf">
      <SHORT-NAME>cdd_lfic_interface</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="c8021c77-6f7a-4544-8906-f90a76e9524b">
      <SHORT-NAME>cdd_rfic_interface</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>